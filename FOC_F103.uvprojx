# Keil uVision project FOC_F103.uvprojx, settings and files
target C8T6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FOC_F103 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\CORE;.\STM32F10x_FWLib\inc;.\STM32F10x_FWLib\src;.\USER;.\USER\uart;.\USER\adc;.\USER\Delay;.\USER\KEY;.\USER\TIM;.\USER\IQS7211E;.\USER\I2C;.\USER\SPI;.\USER\OLED;.\USER\ATK_MW8266D;.\USER\MPU6050;.\USER\MOTOR
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s startup_stm32f10x_md.s
  group FWLIB
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group UART
    ./USER/uart/: bsp_uart.c elog.c elog_port.c elog_utils.c app_log.c
  group ADC
    ./USER/adc/: bsp_adc.c
  group Delay
    ./USER/Delay/: bsp_delay.c
  group KEY
    ./USER/KEY/: app_key.c hal_key.c multi_button.c
  group TIM
    ./USER/TIM/: app_timer.c soft_timer_list.c smarttimer.c
  group IQS7211E
    ./USER/IQS7211E/: IQS7211E.c
  group I2C
    ./USER/I2C/: i2c_bitops.c i2c_core.c i2c_hw.c
  group SPI
    ./USER/SPI/: spi_bitops.c spi_core.c spi_hw.c
  group OLED
    ./USER/OLED/: app_oled.c stm32f4_fonts.c app_menu.c app_dinogame.c
    ./USER/bsp_OLED/: bsp_oled.c bsp_Font.c
    ./USER/bsp_OLED/DISPLAY/: ANIMOTION.C
  group ATKMW8266D
    ./USER/ATK_MW8266D/: atk_mw8266d.c
  group MPU6050
    ./USER/MPU6050/: app_mpu6050.c inv_mpu.c
  group MOTOR
    ./USER/MOTOR/: app_motor.c
